options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    category: Custom
    description: A CW (Morse) Decoder
    generate_options: no_gui
    id: satnogs_cw_decoder
    output_language: python
    run_options: run
    title: CW Decoder
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '8'
  states: {}
- name: dot_samples
  id: variable
  parameters:
    value: int((1.2 / wpm) / (1.0 / (audio_samp_rate / 10.0)))
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-4'
    decay_rate: '1e-4'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    decay_rate: '0.001'
    gain: '0.0'
    max_gain: '65536'
    reference: '0.015'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*math.pi*2500
    min_freq: '-2*math.pi*2500'
    w: 2*math.pi/100
  states: {}
- name: antenna
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: bfo_freq
  id: parameter
  parameters:
    comment: |-
      The bfo_freq shifts the carrier from 0 Hz to a
      frequency that corresponds to the CW audio
      tone. This tone is typically 1 kHz.
    type: eng_float
    value: 1e3
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(dot_samples//dec)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Decimate manually so we
      can avoid an extra filter
    n: '10'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2.0 * math.pi * (bfo_freq / audio_samp_rate)
  states: {}
- name: bw
  id: parameter
  parameters:
    comment: |-
      The bandwidth should configure RF filters on some devices.
      Set to 0.0 for automatic calculation.
    label: Bandwidth
    type: eng_float
    value: '0.0'
  states: {}
- name: decoded_data_file_path
  id: parameter
  parameters:
    type: str
    value: /tmp/.satnogs/data/data
  states: {}
- name: dev_args
  id: parameter
  parameters:
    label: Device arguments
    type: str
    value: ''
  states: {}
- name: doppler_correction_per_sec
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}
- name: enable_iq_dump
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: file_path
  id: parameter
  parameters:
    type: str
    value: test.wav
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1.0] * int(dot_samples//dec)'
    type: ccc
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '0.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import satnogs
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: iq_file_path
  id: parameter
  parameters:
    type: str
    value: /tmp/iq.dat
  states: {}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: 100e3
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate/10
    type: fir_filter_ccf
    width: 0.1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: rigctl_port
  id: parameter
  parameters:
    type: intx
    value: '4532'
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 100e6
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: '0.0'
  states: {}
- name: satnogs_cw_to_symbol_1
  id: satnogs_cw_to_symbol
  parameters:
    conf_level: '0.9'
    hysteresis: dot_samples//dec
    samp_rate: audio_samp_rate/10
    threshold: '2.0'
    wpm: wpm
  states: {}
- name: satnogs_doppler_compensation_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: '1'
    lo_offset: lo_offset
    out_samp_rate: audio_samp_rate
    samp_rate: samp_rate_rx
    sat_freq: rx_freq
  states: {}
- name: satnogs_frame_file_sink_0_0
  id: satnogs_frame_file_sink
  parameters:
    output_type: '0'
    prefix_name: decoded_data_file_path
  states: {}
- name: satnogs_iq_sink_0
  id: satnogs_iq_sink
  parameters:
    activate: enable_iq_dump
    append: 'False'
    filename: iq_file_path
    scale: '16768'
  states: {}
- name: satnogs_morse_decoder_0
  id: satnogs_morse_decoder
  parameters:
    min_frame_len: '3'
    unrecognized_char: ord('#')
  states: {}
- name: satnogs_ogg_encoder_0
  id: satnogs_ogg_encoder
  parameters:
    filename: file_path
    quality: '1.0'
    samp_rate: audio_samp_rate
  states: {}
- name: satnogs_tcp_rigctl_msg_source_0
  id: satnogs_tcp_rigctl_msg_source
  parameters:
    addr: '"127.0.0.1"'
    interval: int(1000.0/doppler_correction_per_sec) + 1
    mode: 'False'
    mtu: '1500'
    port: rigctl_port
  states: {}
- name: satnogs_udp_msg_sink_0_0
  id: satnogs_udp_msg_sink
  parameters:
    addr: udp_IP
    mtu: '1500'
    port: udp_port
  states: {}
- name: satnogs_waterfall_sink_0
  id: satnogs_waterfall_sink
  parameters:
    center_freq: rx_freq
    fft_size: '1024'
    filename: waterfall_file_path
    mode: '1'
    rps: '10'
    samp_rate: audio_samp_rate
  states: {}
- name: soapy_rx_device
  id: parameter
  parameters:
    type: str
    value: driver=invalid
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: dev_args
    balance0: '0'
    bw0: bw
    center_freq0: rx_freq - lo_offset
    correction0: '0'
    dc_offset0: '0'
    dc_offset_auto_mode0: 'False'
    dc_offset_auto_mode1: 'False'
    dev: soapy_rx_device
    devname: custom
    gain_auto_mode0: 'False'
    gain_auto_mode1: 'False'
    manual_gain0: 'False'
    manual_gain1: 'True'
    mix_gain1: '10'
    overall_gain0: gain
    samp_rate: samp_rate_rx
    sdrplay_biastee: 'True'
    tuner_gain1: '10'
    type: fc32
    vga_gain1: '10'
  states: {}
- name: udp_IP
  id: parameter
  parameters:
    type: str
    value: 127.0.0.1
  states: {}
- name: udp_port
  id: parameter
  parameters:
    type: intx
    value: '16887'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: waterfall_file_path
  id: parameter
  parameters:
    type: str
    value: /tmp/waterfall.dat
  states: {}
- name: wpm
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_0_0, '0']
- [analog_agc2_xx_0_0, '0', blocks_rotator_cc_0_0, '0']
- [analog_pll_carriertracking_cc_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_mag_0, '0', satnogs_cw_to_symbol_1, '0']
- [blocks_complex_to_real_0, '0', satnogs_ogg_encoder_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_keep_one_in_n_0, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_0_0, '0', analog_agc2_xx_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_keep_one_in_n_0, '0']
- [satnogs_cw_to_symbol_1, out, satnogs_morse_decoder_0, in]
- [satnogs_doppler_compensation_0, '0', virtual_sink_0, '0']
- [satnogs_morse_decoder_0, out, satnogs_frame_file_sink_0_0, frame]
- [satnogs_morse_decoder_0, out, satnogs_udp_msg_sink_0_0, in]
- [satnogs_tcp_rigctl_msg_source_0, freq, satnogs_doppler_compensation_0, doppler]
- [soapy_source_0, '0', satnogs_doppler_compensation_0, '0']
- [virtual_source_0, '0', analog_agc2_xx_0, '0']
- [virtual_source_0, '0', satnogs_iq_sink_0, '0']
- [virtual_source_0, '0', satnogs_waterfall_sink_0, '0']

metadata:
  file_format: 1
